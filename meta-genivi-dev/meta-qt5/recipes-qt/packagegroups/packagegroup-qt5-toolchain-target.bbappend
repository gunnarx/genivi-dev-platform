
RDEPENDS_${PN}_remove = " \
    qtwebkit \
    qtwebkit-dev \
    qtwebkit-mkspecs \
    qtwebkit-qmlplugins \
"
